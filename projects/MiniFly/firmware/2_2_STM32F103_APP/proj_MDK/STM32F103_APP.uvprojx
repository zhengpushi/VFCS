# Keil uVision project STM32F103_APP.uvprojx, settings and files
target STM32F103_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_APP +hex
  AfterMake: fromelf --bin !L -o .\STM32F103_APP_V1.2.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\COMMON\interface;..\COMMUNICATE\interface;..\CONFIG\interface;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\GUI_APP\interface;..\GUI_DRV\interface;..\HARDWARE\interface;..\RTT;..\USB\STM32_USB-FS-Device_Driver\inc;..\USB\CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8002400 size 0x1dc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CONFIG
    ../CONFIG/src/: config_param.c
    ../CONFIG/interface/: config_param.h
  group COMMUNICATE
    ../COMMUNICATE/src/: atkp.c beep.c joystick.c keyTask.c radiolink.c remoter_ctrl.c usblink.c
  group GUI_APP
    ../GUI_APP/src/: debug_ui.c display.c joystickCalib_ui.c main_ui.c match_ui.c menu_ui.c menuL1_item.c menuL2_item.c menuL3_item.c reset_ui.c trim_ui.c
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c
  group HARDWARE
    ../HARDWARE/src/: 24l01.c adc.c key.c led.c oled.c stmflash.c
  group GUI_DRV
    ../GUI_DRV/src/: button.c font.c gui_basic.c gui_menu.c lcmdrv.c messagebox.c scrollbar.c text.c windows.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_conf.h
  group USB_CORE
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s
  group README
    ../: README.TXT
